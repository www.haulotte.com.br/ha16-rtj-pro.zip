Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:24:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:24:07 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{4CC417ED-21C5-4B77-943F-EDB1FB683B15}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:24:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:24:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:24:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA16 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT:HA16 RTJ PRO:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Red, Metal - Haulotte - Black, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - White
Type - Autre(Type) - Catégorie: Equipement spécialisé; Energy: Thermal - Kubota engine; Machine Weight: 6650 kg (14 663 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Performance & ease of use Excellent working envelope with an offset of 8.3 m Incomparable rise time 40 sec Excellent simultaneity and proportionality of movements 4 steering wheels and 360° continuous turret rotation for better productivity More comfort and safety Activ'Shield Bar 2.0 Haulotte Activ'Lighting System Haulotte for safe charging/discharging in low light conditions Reduced maintenance and operating costs Haulotte Activ'Screen (on-board diagnostics) Haulotte Stop Emission System: automatically turns the engine off/on again Easy access to all components; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA16 RTJ PRO; Nom du type: HA16 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha16-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Drive Speed: 5,2 km/h (3,2mph); Gradeability: 40%; Ground Clearance: 38 cm (15 in); Height - Storage / Transport: 2,4 m (7 ft 10 in); Height - Stowed: 2,3 m (7 ft 7 in); Horizontal Outreach: 8,3 m (27 ft 3 in); Jib Length: 1,5 m ( 4 ft 11 in); Lenght - Storage/Transport: 5,05 m ( 16 ft 7 in); Length - Stowed: 6,75 m (22 ft 2 in); Lift Capacity: 2 persons - 230 kg (500 lbs); Max Ground Pressure of Wheel on Paved Ground: 11,44 daN/cm²; Oscillating Angle: 6,5°; Platform Height: 14,0 m (45 ft 11,18in); Platform Rotation: 165° ( -90° / +75°); Platform Size: 1.83 x 0.80 m (6 ft x 2 ft 7,5 in); Tailswing: 10 cm (4 in); Tilt: 5°; Tires: Cured on solid tires 850 x 340 mm (33.5 x 13.4 in); Turnable Rotation: 360° continuous; Turning Radius - Inside: 2,0 m (6 ft 7 in); Turning Radius - Outside: 3,75 m (12 ft 4 in); Up and Over Clearance: 7,65 m (25 ft 1 in); Vertical Jib Rotation Angle: 140° (-80° / +60°); Wheelbase: 2,1 m ( 6 ft 11 in); Width: 2,3 m (7 ft 7 in); Working Height: 16,0 m (52,5 ft)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA16 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A1: 0 deg; A2: 45 deg; A4: 0 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT: HA16 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT: HA16 RTJ PRO; H: 6.464 m; ID du type: Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT: HA16 RTJ PRO; L1: 6.464 m; L2: 5.36 m; MT: no; R: 0 deg; Type: Construction_Aerial-Equipment_Haulotte_HA16-RTJ-PRO_INT: HA16 RTJ PRO; VJRA: -45 deg; WM: no
Construction - Boom Rotation Angle: 45 deg; Maximum Boom Articulation Point Height: 7.65 m; Platform Rotation Angle: 0 deg; Reach Diagram: no; Telescopic Extend: 5.36 m; Turnable Rotation: 0 deg; Turning Radius: no; Vertical Jib Rotation Angle: -45 deg; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 91.075 m2; Volume: 14.1623 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
